## KernelHello/Kconfig
```kconfig
config HelloGoodbye
	tristate "Linux Kernel Module Hello"
	default m
	depends on MODULES
	help
		Linux Kernel Module Hello
```
